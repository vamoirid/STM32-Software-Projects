<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\3 LED Blink v3.ewp</path>
  </project>
  <batchBuild />
</workspace>
