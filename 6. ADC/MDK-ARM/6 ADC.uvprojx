# Keil uVision project 6 ADC.uvprojx, settings and files
target 6 ADC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 6 ADC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c misc: --C99
  c include: ../Inc;"C:/Users/Vasileios Amoiridis/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Inc";"C:/Users/Vasileios Amoiridis/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy";"C:/Users/Vasileios Amoiridis/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include";"C:/Users/Vasileios Amoiridis/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/CMSIS/Include"
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Vasileios Amoiridis/STM32Cube/Repository/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c
software components: CMSIS:CORE 4.1.0
